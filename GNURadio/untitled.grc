options:
  parameters:
    author: nyr
    generate_options: no_gui
    id: untitled
    output_language: python
    title: Audio-to-FFT-file
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"VoiceMeeter Output"'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: R:\sink.txt
    type: float
    vlen: vec_len
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/1024
    type: complex
    vlen: vec_len
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: vec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '0.005'
    samples_per_second: '20000'
    type: float
    vlen: '256'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: B:\source\Unity\CryptoTestBed\GNURadio\BFG_Division.wav
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr # type: ignore


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          #PATH = "R:/sink.txt"
          #f = open(PATH, 'bw')

          def __init__(self, vectorSize=512):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AppendDelim',   # will show up in GRC
                  in_sig=[(np.float32,vectorSize)],
                  out_sig=[(np.float32,vectorSize)]
                  #PATH = "B:/source/Unity/CryptoTestBed/GNURadio/sink.txt"
                  #f = open(PATH, 'bw')
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * 1.0
              #output_items[0][len(input_items[0])-1] = output_items[0][len(input_items[0])-1] * (-1.0)
              #PATH = "B:/source/Unity/CryptoTestBed/GNURadio/sink.txt"
              #f = open(PATH, 'bw')
              #np.ndarray.tofile(f)
              PATH = "R:/sink.txt"
              f = open(PATH, 'bw')
              output_items[0].tofile(f)
              f.close()
              return len(output_items[0])
    vectorSize: '512'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '512'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(512)
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: float
    update_time: '0.2'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"green"'
    grid: 'True'
    name: '"FFT?"'
    update_time: '0.2'
    vlen: '256'
    x_start: '0'
    x_step: '20000'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_1, '0']
- [audio_source_0, '0', blocks_stream_to_vector_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', fft_vxx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
